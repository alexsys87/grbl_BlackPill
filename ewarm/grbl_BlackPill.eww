<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\grbl_STM32F401CC.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\grbl_STM32F401CE.ewp</path>
    </project>
    <batchBuild />
</workspace>
