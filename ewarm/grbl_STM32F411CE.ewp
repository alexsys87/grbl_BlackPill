# IAR project grbl_STM32F411CE.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411CE ST STM32F411CE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F411xE
  ICCARM.PreInclude: ..\driver\cnc3018_defaults.h
  ICCARM.CCIncludePath2: ..; ..\cmsis\core; ..\cmsis\device; ..\driver
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: grbl_STM32F411CE.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\cmsis\linker\stm32f411xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group cmsis
    ../cmsis/: system_stm32f4xx.c
    ../cmsis/startup/: startup_stm32f411xe.s
  group driver
    ../driver/: compat.c cpu.c driver.c ioports_aux.c main.c nvs_flash.c serial.c spindle.c stream_mux.c usb_cdc.c cnc3018_defaults.h driver.h my_machine.h
  group driver/boards
    ../driver/boards/: cnc3018_blackpill_map.h
  group grbl
    ../grbl/: alarms.c canbus.c coolant_control.c crc.c crossbar.c encoders.c errors.c fs_device.c fs_embedded.c fs_ram.c gcode.c grbllib.c ioports.c machine_limits.c messages.c modbus.c modbus_rtu.c motion_control.c my_plugin.c ngc_expr.c ngc_flowctrl.c ngc_params.c nuts_bolts.c nvs_buffer.c override.c pid.c planner.c probe.c protocol.c regex.c report.c settings.c sleep.c spindle_control.c state_machine.c stepper.c stepper2.c stream.c stream_file.c stream_json.c stream_passthru.c strutils.c system.c tool_change.c utf8.c vfs.c
  group grbl/kinematics
    ../grbl/kinematics/: asymmetric_ganging.c corexy.c delta.c polar.c rtcp_ac.c wall_plotter.c
